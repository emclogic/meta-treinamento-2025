PACKAGECONFIG:append = " drm fbdev "