FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://tux-yocto-emc.png;outsuffix=default"
