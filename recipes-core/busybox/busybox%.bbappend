FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://misc.cfg"