
KERNEL_DEVICETREE:append = " overlays/pmw1-overlay.dtbo"

KERNEL_DEVICETREE:append "overlays/i2c1.dtbo"
