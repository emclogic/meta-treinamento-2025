require recipes-images/images/core-image.inc
