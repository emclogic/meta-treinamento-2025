EXTRA_OECONF:append = " --enable-tools"

PACKAGECONFIG:append:${PN} = " python3"
